SRC_URI += "file://devmem.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

